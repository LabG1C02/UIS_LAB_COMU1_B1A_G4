options:
  parameters:
    author: DiegoEspinel_DiegoGarcia_B1A_G2
    generate_options: qt_gui
    id: Parte_B_Filtrado
    output_language: python
    title: LAB1_ParteB_Punto6
  states: {}

blocks:
- name: BW
  id: variable_qtgui_range
  parameters:
    label: Ancho de Banda
    start: '10'
    step: '10'
    stop: '50000'
    value: '1500'
  states: {}
- name: F_corte
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Corte
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Central
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44093'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: Fc+BW/2
    interp: '1'
    low_cutoff_freq: Fc-BW/2
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\INGENIERIA ELECTRONICA\11. Onceavo Semestre\Comunicaciones I\LABS Comu I\Laboratorio_1\ParteB_Freq_MuestreoGNURadio\gitana_williecolon.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: F_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: F_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Interpolación
    label2: Diezmado
    nconnections: '2'
    type: float
    width1: '2'
    width2: '2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    type: fff
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [band_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
